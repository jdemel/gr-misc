<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_fft_qt</value></param>
<param><key>title</key><value>UHD FFT Qt</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_serial</value></param>
<param><key>value</key><value>z_info["mboard_serial"]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_id</value></param>
<param><key>value</key><value>z_info["mboard_id"]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>info_init</value></param>
<param><key>value</key><value>{"mboard_id":"id","mboard_serial":"serial","rx_serial":"rx","rx_subdev_name":"subname"}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>actual_rf</value></param>
<param><key>value</key><value>catch_result.actual_rf_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>actual_dsp</value></param>
<param><key>value</key><value>catch_result.actual_dsp_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>master_clock_rate</value></param>
<param><key>value</key><value>40e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_type</value></param>
<param><key>value</key><value>"b200"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>db_text</value></param>
<param><key>value</key><value>db_name + " (" + db_serial  + " ," + db_spec + " ," + db_antenna + ")"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_text</value></param>
<param><key>value</key><value>usrp_id + " (" + usrp_serial + ")"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_args</value></param>
<param><key>value</key><value>"type=" + usrp_type + ",master_clock_rate=" + str(master_clock_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_args_b200</value></param>
<param><key>value</key><value>dev_args</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>myzero</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>db_serial</value></param>
<param><key>value</key><value>z_info["rx_serial"]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>db_name</value></param>
<param><key>value</key><value>z_info["rx_subdev_name"]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import uhd</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>uhd_version</value></param>
<param><key>label</key><value>UHD</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>uhd.get_version_string()</value></param>
<param><key>gui_hint</key><value>3, 0, 1, 1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>0, 0, 3, 5</value></param>
<param><key>freqchangevar</key><value>None</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>10e6</value></param>
<param><key>gui_hint</key><value>4, 0, 1, 3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>5, 0, 1, 5</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>usrp_dev</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>dev_args_b200</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value>RX2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio import uhd</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>dsp_label</value></param>
<param><key>label</key><value>DSP Freq</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>actual_dsp</value></param>
<param><key>gui_hint</key><value>3, 4, 1, 1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>rf_label</value></param>
<param><key>label</key><value>RF Freq</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>actual_rf</value></param>
<param><key>gui_hint</key><value>3, 3, 1, 1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>900e6</value></param>
<param><key>gui_hint</key><value>4, 3, 1, 2</value></param>
</block>
<block>
<key>variable_catch_result</key>
<param><key>id</key><value>catch_result</value></param>
<param><key>value</key><value>uhd.tune_result()</value></param>
<param><key>block_id</key><value>usrp_dev</value></param>
<param><key>func</key><value>set_center_freq</value></param>
<param><key>params</key><value>center_freq, myzero</value></param>
</block>
<block>
<key>variable_catch_result</key>
<param><key>id</key><value>db_antenna</value></param>
<param><key>value</key><value>"antenna"</value></param>
<param><key>block_id</key><value>usrp_dev</value></param>
<param><key>func</key><value>get_antenna</value></param>
<param><key>params</key><value>0</value></param>
</block>
<block>
<key>variable_catch_result</key>
<param><key>id</key><value>db_spec</value></param>
<param><key>value</key><value>"spec"</value></param>
<param><key>block_id</key><value>usrp_dev</value></param>
<param><key>func</key><value>get_subdev_spec</value></param>
<param><key>params</key><value>0</value></param>
</block>
<block>
<key>variable_catch_result</key>
<param><key>id</key><value>z_info</value></param>
<param><key>value</key><value>info_init</value></param>
<param><key>block_id</key><value>usrp_dev</value></param>
<param><key>func</key><value>get_usrp_info</value></param>
<param><key>params</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>a_usrp</value></param>
<param><key>label</key><value>USRP</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>value</key><value>usrp_text</value></param>
<param><key>gui_hint</key><value>3, 1, 1, 1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>a_db_label</value></param>
<param><key>label</key><value>Daughterboard</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>db_text</value></param>
<param><key>gui_hint</key><value>3, 2, 1, 1</value></param>
</block>
<connection><source_block_id>usrp_dev</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
