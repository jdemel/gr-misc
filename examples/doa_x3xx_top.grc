<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>port</value></param>
<param><key>value</key><value>47110</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>keep_plot</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseband_rate</value></param>
<param><key>value</key><value>int(samp_rate/decim)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>150</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cal_freq</value></param>
<param><key>value</key><value>450e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>7.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_antenna</value></param>
<param><key>value</key><value>"RX2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_keep</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mlen</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M_keep</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>device_args</value></param>
<param><key>value</key><value>"type=x300, master_clock_rate=150e6"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_gain</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>angular_resolution</value></param>
<param><key>value</key><value>360</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>"10.16.32.209"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip</value></param>
<param><key>value</key><value>"localhost"</value></param>
</block>
<block>
<key>xlate_interleave</key>
<param><key>id</key><value>xlate_interleave_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>xlate_bw</key><value>xlate_bw</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>label</key><value>Xlate Freq. Offset</value></param>
<param><key>value</key><value>200e3</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tabw@0:0,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>xlate_bw</value></param>
<param><key>label</key><value>Xlate Bandwidth</value></param>
<param><key>value</key><value>25e3</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>baseband_rate</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tabw@0:0,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>usrp_gain</value></param>
<param><key>label</key><value>USRP RF Gain</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>33</value></param>
<param><key>gui_hint</key><value>tabw@0:0,3,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>calib_freq_offset</value></param>
<param><key>label</key><value>Calibration Tone Offset</value></param>
<param><key>value</key><value>2e6</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>tabw@0:0,0,1,1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>math.e**(1.0j*phase)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>200e3</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-3</value></param>
<param><key>stop</key><value>3</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>doa_channel_phase_correction</key>
<param><key>id</key><value>doa_channel_phase_correction_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>mlen</key><value>mlen</value></param>
<param><key>decim</key><value>50</value></param>
<param><key>freq_offset</key><value>calib_freq_offset</value></param>
<param><key>samp_rate</key><value>7.5e6</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>device_args</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>cal_freq</value></param>
<param><key>gain0</key><value>usrp_gain</value></param>
<param><key>ant0</key><value>rx_antenna</value></param>
<param><key>center_freq1</key><value>cal_freq</value></param>
<param><key>gain1</key><value>usrp_gain</value></param>
<param><key>ant1</key><value>rx_antenna</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>Phase Difference</value></param>
<param><key>size</key><value>1024*10</value></param>
<param><key>srate</key><value>samp_rate/(1.*N_keep/M_keep)</value></param>
<param><key>ymin</key><value>-3.2</value></param>
<param><key>ymax</key><value>3.2</value></param>
<param><key>gui_hint</key><value>tabw@0:1,3,2,1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>cal_freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>tabw@0:1,0,2,3</value></param>
<param><key>freqchangevar</key><value>None</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>n</key><value>keep</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>keep</value></param>
<param><key>label</key><value>Keep input vectors</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tabw@1:2,1,1,1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabw</value></param>
<param><key>num_tabs</key><value>2</value></param>
<param><key>label0</key><value>Synchronization Setup</value></param>
<param><key>label1</key><value>DOA</value></param>
</block>
<block>
<key>misc_music_doa</key>
<param><key>id</key><value>misc_music_doa_1</value></param>
<param><key>m</key><value>2</value></param>
<param><key>n</key><value>1</value></param>
<param><key>nsamples</key><value>N</value></param>
<param><key>angular_resolution</key><value>angular_resolution</value></param>
<param><key>freq</key><value>cal_freq</value></param>
<param><key>spacing</key><value>0.132</value></param>
<param><key>antenna_array</key><value>[[0,0],[1,0]]</value></param>
<param><key>output_spectrum</key><value>True</value></param>
</block>
<block>
<key>missile_launcher</key>
<param><key>id</key><value>missile_launcher_0</value></param>
<param><key>az</key><value>0.0</value></param>
<param><key>el</key><value>25.0</value></param>
<param><key>fire</key><value>fire</value></param>
<param><key>thresh</key><value>0.0</value></param>
<param><key>recal_threshold</key><value>0.0</value></param>
<param><key>cal</key><value>True</value></param>
</block>
<block>
<key>misc_compass</key>
<param><key>id</key><value>misc_compass_0</value></param>
<param><key>use_radians</key><value>False</value></param>
<param><key>needle_type</key><value>"simple"</value></param>
<param><key>needle_style</key><value>"nice"</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>gui_hint</key><value>tabw@1:0,1,1,1</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>misc_numbersink</key>
<param><key>id</key><value>misc_numbersink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Angle</value></param>
<param><key>units</key><value>Degrees</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>minval</key><value>0</value></param>
<param><key>maxval</key><value>360</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0.0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>gui_hint</key><value>tabw@1:1,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>fire</value></param>
<param><key>label</key><value>FIRE!</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tabw@1:2,0,1,1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>angular_resolution</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>MUSIC Spectrum</value></param>
<param><key>size</key><value>angular_resolution</value></param>
<param><key>srate</key><value>1.0/1000.0</value></param>
<param><key>ymin</key><value>-3.0</value></param>
<param><key>ymax</key><value>20.0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tabw@1:0,0,2,1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>keep_plot</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Keep 1 in N</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>64*0 + 16</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>k</key><value>0</value></param>
<param><key>vlen</key><value>angular_resolution</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>keep_plot</value></param>
<param><key>vlen</key><value>angular_resolution</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>tcp_spectrum_sink</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>addr</key><value>ip</value></param>
<param><key>port</key><value>port + 2</value></param>
<param><key>server</key><value>True</value></param>
<param><key>vlen</key><value>angular_resolution</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>tcp_angle_sink</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>addr</key><value>ip</value></param>
<param><key>port</key><value>port</value></param>
<param><key>server</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>tcp_level_sink</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>addr</key><value>ip</value></param>
<param><key>port</key><value>port + 1</value></param>
<param><key>server</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>doa_channel_phase_correction_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_channel_phase_correction_0</source_block_id><sink_block_id>xlate_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>doa_channel_phase_correction_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>xlate_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>doa_channel_phase_correction_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>misc_music_doa_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>misc_music_doa_1</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>xlate_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>xlate_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlate_interleave_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>tcp_angle_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>misc_numbersink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>missile_launcher_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>misc_compass_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>misc_music_doa_1</source_block_id><sink_block_id>tcp_level_sink</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>misc_music_doa_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>misc_music_doa_1</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>tcp_spectrum_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
