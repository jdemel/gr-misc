<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mimo_tx_ofdm</value></param>
<param><key>title</key><value>MIMO OFDM Tx</value></param>
<param><key>description</key><value>Example of an OFDM Transmitter</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>MIMO</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_formatter</value></param>
<param><key>value</key><value>digital.packet_header_ofdm(occupied_carriers, header_nsyms, length_tag_key)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>label</key><value>Occupied Carriers</value></param>
<param><key>value</key><value>(range(-26, -21) + range(-20, -7) + range(-6, 0) + range(1, 7) + range(8, 21) + range(22, 27),)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>length_tag_key</value></param>
<param><key>label</key><value>Length Tag Key</value></param>
<param><key>value</key><value>packet_len</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>payload_mod.bits_per_symbol()</value></param>
<param><key>len_tag_key</key><value>length_tag_key</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>header_mod.points()</value></param>
<param><key>dimension</key><value>1</value></param>
</block>
<block>
<key>digital_packet_headergenerator_bb</key>
<param><key>id</key><value>digital_packet_headergenerator_bb_0</value></param>
<param><key>header_formatter</key><value>header_formatter.formatter()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>header_mod</value></param>
<param><key>label</key><value>Header Mod</value></param>
<param><key>value</key><value>digital.constellation_bpsk()</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>Pre-OFDM</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ninputs</key><value>2</value></param>
<param><key>lengthtagname</key><value>length_tag_key</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>payload_mod.points()</value></param>
<param><key>dimension</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>header_nsyms</value></param>
<param><key>label</key><value>N Header Symbols</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0</value></param>
<param><key>check</key><value>False</value></param>
<param><key>lengthtagname</key><value>length_tag_key</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>source</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>payload_mod</value></param>
<param><key>label</key><value>Payload Mod</value></param>
<param><key>value</key><value>digital.constellation_qpsk()</value></param>
</block>
<block>
<key>digital_ofdm_carrier_allocator_cvc</key>
<param><key>id</key><value>digital_ofdm_carrier_allocator_cvc_0</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>sync_words</key><value>(sync_word1, sync_word2)</value></param>
<param><key>len_tag_key</key><value>length_tag_key</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>label</key><value>CP length</value></param>
<param><key>value</key><value>16</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>label</key><value>Symbol Rolloff</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>FFT length</value></param>
<param><key>value</key><value>64</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>10. ** (1.*db_gain/10)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>label</key><value>TX Freq</value></param>
<param><key>value</key><value>905e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>db_gain</value></param>
<param><key>label</key><value>Output Backoff</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Samp Rate</value></param>
<param><key>value</key><value>250e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>USRP source gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_word1</value></param>
<param><key>label</key><value>Sync Word 1</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>label</key><value>Pilot Symbols</value></param>
<param><key>value</key><value>((1, 1, 1, -1,),)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pilot_carriers</value></param>
<param><key>label</key><value>Pilot Carriers</value></param>
<param><key>value</key><value>((-21, -7, 7, 21,),)</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>Pre-OFDM</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>()</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_word2</value></param>
<param><key>label</key><value>Sync Word 2</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] </value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dev</value></param>
<param><key>label</key><value>Device Addr</value></param>
<param><key>value</key><value>'type=usrp2'</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>dev</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>input_size</key><value>fft_len</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>rolloff</key><value>rolloff</value></param>
<param><key>tagname</key><value>length_tag_key</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>digital_packet_headergenerator_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>digital_packet_headergenerator_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>source</source_block_id><sink_block_id>digital_crc32_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>digital_ofdm_carrier_allocator_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_carrier_allocator_cvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
