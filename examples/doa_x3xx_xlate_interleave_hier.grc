<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>xlate_interleave</value></param>
<param><key>title</key><value>Xlate Channels and Interleave</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>DOA</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, xlate_bw/2, 5000*2)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Samp Rate (Msps)</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>value</key><value>150</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>xlate_bw</value></param>
<param><key>label</key><value>Xlate Bandwidth</value></param>
<param><key>value</key><value>25e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>xlate_taps</value></param>
<param><key>center_freq</key><value>freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>xlate_taps</value></param>
<param><key>center_freq</key><value>freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
